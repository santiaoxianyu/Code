# Keil uVision project ncontroller.uvprojx, settings and files
target ncontroller (6180000::V6.18::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G_DFP.1.2.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ncontroller +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: __MSPM0G3507__
  c include: ..\source\third_party\CMSIS\Core\Include;..\source;..\;..\driver;..\user;..\apply;..\apply\developer;..\apply\Fusion;..\NewCode;..\..\mspm0g3507_20240729
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group sources
    ../source/ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_i2c.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc_common.c dl_spi.c dl_timer.c dl_trng.c dl_uart.c dl_vref.c
    ../source/ti/driverlib/m0p/: dl_interrupt.c
    ../source/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0g1x0x_g3x0x.c
    ../source/ti/devices/msp/m0p/startup_system_files/keil/: startup_mspm0g350x_uvision.s
  group user
    ../: ncontroller.syscfg ti_msp_dl_config.c ti_msp_dl_config.h
    ../user/: main.c datatype.h headfile.h
  group driver
    ../driver/: system.c oled.c ssd1306.c ntimer.c npwm.c nqei.c nppm.c nadc.c nuart.c ni2c.c icm20608.c nbutton.c ngpio.c neeprom.c w25qxx.c us100.c ICM42688.C ICM42688.h bno08x.c bno08x.h drv_imu.c drv_imu.h bsp_mpu6050.c bsp_mpu6050.h dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h jy61p.c jy61p.h usart3.c usart3.h
  group app
    ../apply/: user.h rgb.c wp_math.c pid.c ui.c rc.c sensor.c filter.c gray_detection.c self_balancing.c motor_control.c sdk.c vision.c nclink.c attitude_selfstable.c
  group app/developer
    ../apply/developer/: developer_mode.c subtask.c
  group app/fusion
    ../apply/Fusion/: FusionAhrs.c FusionCompass.c FusionOffset.c
  group NewCode
    ../NewCode/: mission.c mission.h grayscale.c grayscale.h BeepLedTips.c BeepLedTips.h Control.c Control.h pid_2.c pid_2.h vofa.c vofa.h
