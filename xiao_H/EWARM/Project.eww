<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\xiao_H.ewp</path>
  </project>
  <batchBuild />
</workspace>
